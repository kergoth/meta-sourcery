FILES_${PN}_append_tcmode-external-sourcery = " ${exec_prefix}/license"
WARN_QA_remove_tcmode-external-sourcery = " libdir"
ERROR_QA_remove_tcmode-external-sourcery = " libdir"
